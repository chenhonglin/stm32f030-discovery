# Keil uVision project Lesson6_USART_3_DMA_TXRX.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Lesson6_USART_3_DMA_TXRX
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c drv_dma.h drv_usart.h drv_dma.c drv_usart.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.5.0
